<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NRF_controll.ewp</path>
  </project>
  <batchBuild />
</workspace>
